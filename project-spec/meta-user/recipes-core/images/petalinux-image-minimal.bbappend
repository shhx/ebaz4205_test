IMAGE_INSTALL:append = " libiio"
IMAGE_INSTALL:append = " libiio-tests"
IMAGE_INSTALL:append = " libiio-python3"
